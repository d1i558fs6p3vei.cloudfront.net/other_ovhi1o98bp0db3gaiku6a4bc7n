Properties of the parts of a building model (IFC4), part 2 of 2

# IfcFlowTerminal: nextVIT WT-Element Wandbatterie Systembauhöhe 120:nextVIT WT-Element Wandbatterie Systembauhöhe 120, nextVIT WT-Element Wandbatterie Systembauhöhe 120:nextVIT WT-Element Wandbatterie Systembauhöhe 120:7638789
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für Waschtisch-Wandbatterie - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - werkzeuglos höhenverstellbare, rutschhemmende Anschlusstraversen für Wasseranschluss, Ablauf, Keramikbefestigung - Lochabstand Keramikbefestigung max. 400 mm - Montage handelsüblicher Wandscheiben G 1/2 möglich - Elementhöhe auf Keramik anpassbar, erweiterbar von 1150 bis 1325 mm LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - 2 schallgedämmte MEPA-Wandscheiben G 1/2 - höhenverstellbarer Ablaufbogenhalter - HT-Ablaufbogen DN 50 mit Gummimanschette NW 30/50 - Befestigung Keramik Schichtholzplatte 420x100x38 mm - 2 Stockschrauben M10 - Fußverlängerungsset 175 mm - Befestigungsmaterial ZUBEHÖR - Wandwinkel-Set zur Einzelmontage EC-Technik (Art.-Nr. 541023) HINWEISE Kein Verwendungshinweis notwendig; MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952027776; MEPA_ID: 522002; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT Waschtisch-Element Wandbatterie/Ausgussbecken Systembauhöhe 120; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 12.6 Kilogramm

# IfcFlowTerminal: nextVIT Waschtisch-Element Wasserzählerstrecke WZ2 Rotguss:nextVIT Waschtisch-Element Wasserzählerstrecke WZ2 Rotguss, nextVIT Waschtisch-Element Wasserzählerstrecke WZ2 Rotguss:nextVIT Waschtisch-Element Wasserzählerstrecke WZ2 Rotguss:7638216
In: Ebene 0
Type - Material: MEPA Steel, MEPA Grey Glossy, MEPA White Glossy, MEPA Plastic red 255-0-0, MEPA Plastic black 90-90-90, MEPA Steel black 80-80-80, MEPA Insulation soft, MEPA Plastic white, <Unnamed>
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für Waschtisch-Einlochbatterie - zum Einbau von Messkapseln KOAX G 2 - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - werkzeuglos höhenverstellbare, rutschhemmende Anschlusstraversen für Wasseranschluss und Wasserzählerstrecke, Ablauf, Keramikbefestigung - Lochabstand Keramikbefestigung 150-240 mm - Schall- und wärmegedämmte Wasserzählerstrecke Warm/Kalt für vertikale Installation, anschlussfertig vormontiert und dichtgeprüft, bestehend aus: - einteilig gegossene Wasserzählerstrecke aus Rotguss, Anschlüsse primärseitig G3/4,sekundärseitig G1/2, für gängige UP-Wasserzählerfabrikate KOAX G 2 bis Q3 = 2,5 m³/h laut MID, in durchgeschleifter Ausführung zur Einbindung in Reihen- oder Ringleitungen - Rotguss-Wandanschlüsse verdrehsicher und spannungsfrei gelagert - Armaturenanschlüsse und Rohrenden mit Schutzstopfen, hygienisch verschlossen - Isolierkörper aus geschlossenzelligem Polyurethan-Schaum (PUR), Wärmedämmung 100% nach GEG/DIN 1988-200, Wärmeleitfähigkeit Boxkörper 0,037 W/(m x K) bei 40 °C, Raumgewicht größer 55 Kg/m³, Brandverhalten Baustoffklasse B2 gemäß DIN 4102-1, Klasse E gemäß DIN EN 13501-1 LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - Wasserzählerstrecke Warm/Kalt, Rotguss, anschlussfertig vormontiert - RAUPIANO Ablaufbogen DN 50 mit Gummimanschette NW 32/40, mit Bauschutzstopfen - Bauschutzkappen für Ventile und Wasserzählerunterteile - 2 Gewindebolzen M10 - Befestigungsmaterial ZUBEHÖR - Wandwinkel Einzelmontage EC-Technik (Art.-Nr. 541023) - Wasserzähler Fertigmontageset UP-Ventil WZ fix (Art.-Nr. 548018) - Wasserzähler Fertigmontageset UP-Ventil WZ variabel (Art.-Nr. 548019) HINWEISE Kein Verwendungshinweis notwendig; MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952029787; MEPA_ID: 521027; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT Waschtisch-Element Einlochbatterie Systembauhöhe 120 Wasserzählerstrecke WZ2 Messing; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 16 Kilogramm
