Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 79ea8a30-4d37-42da-a535-9bb01cb1420f, VersionGUID: 89145347-65ea-4c41-83c7-a088571ab755, NumberOfSaves: 31], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Intern]
File name: IFC 2x3 CV 2.0 MEPA Gallery.ifc
Time: 2026-01-08T12:47:07+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.4.0.32 (ENG) - 26.4.0.32

# IfcProject, 2018-03
LongName: Projektname; Phase: TEMPLATE

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 mm

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 mm

# IfcDistributionPort (56)
Description: Flow
Name | FlowDirection
OutPort_7637694_1 | SOURCE
InPort_7637694_2 | SINK
InPort_7637694_3 | SINK
OutPort_7637914_3 | SOURCE
InPort_7637914_4 | SINK
OutPort_7638066_1 | SOURCE
InPort_7638066_3 | SINK
Port_7638066_4 | SOURCEANDSINK
OutPort_7638147_3 | SOURCE
InPort_7638147_5 | SINK
OutPort_7638216_1 | SOURCE
InPort_7638216_2 | SINK
InPort_7638216_3 | SINK
OutPort_7638216_4 | SOURCE
OutPort_7638216_5 | SOURCE
InPort_7638396_4 | SINK
OutPort_7638396_5 | SOURCE
InPort_7638464_4 | SINK
OutPort_7638464_5 | SOURCE
OutPort_7638604_1 | SOURCE
InPort_7638604_2 | SINK
InPort_7638604_3 | SINK
OutPort_7638674_1 | SOURCE
InPort_7638674_2 | SINK
InPort_7638674_3 | SINK
OutPort_7638734_1 | SOURCE
InPort_7638734_2 | SINK
InPort_7638734_3 | SINK
InPort_7638789_1 | SINK
InPort_7638789_2 | SINK
OutPort_7638789_3 | SOURCE
InPort_7642642_4 | SINK
OutPort_7642642_5 | SOURCE
InPort_7643403_4 | SINK
OutPort_7643403_5 | SOURCE
OutPort_7643585_1 | SOURCE
InPort_7643585_2 | SINK
InPort_7643585_3 | SINK
OutPort_7643596_1 | SOURCE
InPort_7643596_2 | SINK
InPort_7643596_3 | SINK
InPort_8952229_1 | SINK
InPort_8952229_2 | SINK
InPort_8980214_1 | SINK
OutPort_8980214_2 | SOURCE
InPort_8980374_1 | SINK
OutPort_8980374_2 | SOURCE
InPort_9007708_4 | SINK
OutPort_9007708_5 | SOURCE
InPort_9007708_6 | SINK
InPort_9419840_4 | SINK
OutPort_9419840_5 | SOURCE
InPort_9420068_4 | SINK
OutPort_9420068_5 | SOURCE
InPort_9450203_1 | SINK
InPort_9450203_2 | SINK

# IfcFlowTerminal: nextVIT Air-WC-Element Typ A31 SBH 120:nextVIT Air-WC-Element Typ A31 SBH 120 (2)
In: Ebene 0
Type - Material: MEPA Plastic black 90-90-90, MEPA Steel, MEPA Polystyrene grey, MEPA White Matte, MEPA Porcelain white, MEPA Plastic red 255-0-0, MEPA Steel black 80-80-80
IFC Export - MEPA_Order Quantity: 1; MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_Manufacturer: MEPA; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025
Name (nextVIT Air-WC-Element Typ A31 SBH 120:nextVIT Air-WC-Element Typ A31 SBH 120:...) | MEPA_Description | MEPA_GTIN | MEPA_ID | MEPA_Name | MEPA_Weight
8980214 | VERWENDUNGSZWECK - vormontiertes Montageelement für wandhängendes WC - zur Geruchsabsaugung - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - UP-Spülkasten Sanicontrol Typ A31 - 2-Mengen- oder 1-Mengen- oder Start/Stopp-Spültechnik - EasyConnect-System für werkzeuglose Montage am Spülkasten - Spülkasten komplett vormontiert - Prüfung und CE-Kennzeichnung gemäß DIN EN 14 055 - Wasseranschluss rechts - Spülmenge 6/3 l (Werkseinstellung) - Spülmengen getrennt einstellbar: große Spülmenge 5 - 7 l, stufenlos kleine Spülmenge 3 - 4,5 l, stufenlos - maximales Spülvolumen 7,5 l - bei Werkseinstellung sofortiges Nachspülen möglich - integrierte Spülstromdrossel zur stufenlosen Reduzierung des Spülstroms von ca. 2,2 l/s (min. Drosselung) bis ca. 1,8 l/s (max. Drosselung) - schwitzwassergedämmt - 25 Jahre Ersatzteilgarantie gemäß den MEPA-Garantiebedingungen - mechanische Betätigung von vorn - WC-Anschlussbogen 3-fach tiefenverstellbar - Anschluss Dusch-WC-Systeme möglich - Geruchsabsaugung mit integriertem Radiallüfter - Lüfterbetrieb manuell oder elektronisch - Dehzahlregulierung - 230/24 DC Volt Netzbetrieb über integriertes UP-Netzgerät, Schutzart IP 54 - leckluftdichte Rückschlagklappe LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - Wasseranschluss G 1/2 A mit integriertem Eckventil und Handrad - PE Wand-WC-Anschlussbogen DN 90 - PE Wand-WC-Anschlussgarnitur DN 90 - PE Übergangsstück DN 90/110 - Wand-WC-Befestigungsset M12 - Bauschutzkasten für Revisionsöffnung - 2 Schutzstopfen - Rohranschluss-Set für Lüfter - Befestigungsmaterial ZUBEHÖR - Wandwinkel zur Einzelmontage vor Massivwand (Art. 541023) - Betätigungsplatten Serie MEPA Zero Lumo - Betätigungsplatten Serie MEPA Zero - Betätigungsplatten Serie MEPA Orbit - Betätigungsplatten Serie MEPA Frame - Betätigungsplatten Serie MEPA Sun HINWEISE - bei Betrieb mit der Betätigungsplatte Zero Lumo kann der Lüfter entweder manuell oder automatisch angesteuert werden - Aufgrund der geringen Lüfterleistung und dem damit verbundenen begrenzten Abluftvolumen, darf das Air-WC nicht als Ersatz für eine Raumentlüftung gemäß DIN 18017 eingesetzt werden. - Für bestimmte WC-Keramiken nicht geeignet. Eine ständig aktualisierte Liste von WC-Keramiken , die mit dem Air-WC nicht kompatibel sind, finden Sie unter: www.mepa.de/Download/Planungshilfen - Ausführliche Informationen zu den MEPA Garantiebedingungen finden Sie unter: www.mepa.de/mepa/garantie | 4027952027431 | 514820 | nextVIT Air-WC-Element Typ A31 Systembauhöhe 120 Lüfter manuell | 17.9 Kilogramm
8980374 | VERWENDUNGSZWECK - vormontiertes Montageelement für wandhängendes WC - zur Geruchsabsaugung - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - UP-Spülkasten Sanicontrol Typ A31 - 2-Mengen- oder 1-Mengen- oder Start/Stopp-Spültechnik - EasyConnect-System für werkzeuglose Montage am Spülkasten - Spülkasten komplett vormontiert - Prüfung und CE-Kennzeichnung gemäß DIN EN 14 055 - Wasseranschluss rechts - Spülmenge 6/3 l (Werkseinstellung) - Spülmengen getrennt einstellbar: große Spülmenge 5 - 7 l, stufenlos kleine Spülmenge 3 - 4,5 l, stufenlos - maximales Spülvolumen 7,5 l - bei Werkseinstellung sofortiges Nachspülen möglich - integrierte Spülstromdrossel zur stufenlosen Reduzierung des Spülstroms von ca. 2,2 l/s (min. Drosselung) bis ca. 1,8 l/s (max. Drosselung) - schwitzwassergedämmt - 25 Jahre Ersatzteilgarantie gemäß den MEPA-Garantiebedingungen - mechanische Betätigung von vorn - WC-Anschlussbogen 3-fach tiefenverstellbar - Anschluss Dusch-WC-Systeme möglich - Geruchsabsaugung mit integriertem Radiallüfter - Lüfterbetrieb elektronisch - Dehzahlregulierung - 230/24 DC Volt Netzbetrieb über integriertes UP-Netzgerät, Schutzart IP 54 - leckluftdichte Rückschlagklappe LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - Wasseranschluss G 1/2 A mit integriertem Eckventil und Handrad - PE Wand-WC-Anschlussbogen DN 90 - PE Wand-WC-Anschlussgarnitur DN 90 - PE Übergangsstück DN 90/110 - Wand-WC-Befestigungsset M12 - Bauschutzkasten für Revisionsöffnung - 2 Schutzstopfen - Rohranschluss-Set für Lüfter - Befestigungsmaterial ZUBEHÖR - Wandwinkel Einzelmontage EC-Technik (Art.-Nr. 541023) - Betätigungsplatten Serie MEPA Zero - Betätigungsplatten Serie MEPA Orbit - Betätigungsplatten Serie MEPA Frame - Betätigungsplatten Serie MEPA Sun HINWEISE - aufgrund der geringen Lüfterleistung und dem damit verbundenen begrenzten Abluftvolumen, darf das Air-WC nicht als Ersatz für eine Raumentlüftung gemäß DIN 18017 eingesetzt werden - für bestimmte WC-Keramiken nicht geeignet; eine ständig aktualisierte Liste von WC-Keramiken, die mit dem Air-WC nicht kompatibel sind, finden Sie unter: www.mepa.de/Download/Planungshilfen - ausführliche Informationen zu den MEPA Garantiebedingungen finden Sie unter: www.mepa.de/mepa/garantie - die Empfindlichkeit des HF-Sensors kann durch Bekleidungsplatten und Fliesen beeinflusst werden, die gewünschte Ansprechempfindlichkeit kann nach der Installation an der Tastatur der Elektronik eingestellt werden. Fliesen und Plattenbeläge sowie Betätigungsplatten aus Metall oder mit metallischen Bestandteilen sind für das System nicht geeignet! Die maximale Aufbaustärke beträgt 40 mm ab Vorderkante WC-Rahmen und darf nicht überschritten werden; weitere Hinweise finden Sie in der Montageanleitung | 4027952027462 | 514821 | nextVIT Air-WC-Element Typ A31 Systembauhöhe 120 Lüfter Automatisch | 18.5 Kilogramm

# IfcFlowTerminal: nextVIT Montageelement Dusch und Badewannenarmatur:nextVIT Montageelement Dusch und Badewannenarmatur, nextVIT Montageelement Dusch und Badewannenarmatur:nextVIT Montageelement Dusch und Badewannenarmatur:8952229
In: Ebene 0
Type - Material: MEPA Steel
Material: MEPA Steel, MEPA Plastic red 255-0-0, MEPA Plastic black 90-90-90, MEPA Steel black 80-80-80, MEPA Wood
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für Dusch- oder Badewannenarmatur Aufputz - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - werkzeuglos höhenverstellbare, rutschhemmende AP-Armaturenplatte - Elementhöhe erweiterbar von 1150 bis 1325 mm LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - AP-Armaturenplatte Schichtholzplatte 422x100x21 mm - 2 schallgedämmte MEPA-Wandscheiben G 1/2 - Fußverlängerungsset 175 mm - Befestigungsmaterial ZUBEHÖR - Wandwinkel Einzelmontage EC-Technik (Art.-Nr. 541023) HINWEISE - kürzbar bis Systembauhöhe 850 mm mit Umbauset C-Schiene EC Systembauhöhe 85-100 (Art.-Nr. 542052); MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952027967; MEPA_ID: 549014; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT Montageelement Dusch-/Badewannenarmatur AP; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 9.5 Kilogramm

# IfcFlowTerminal: nextVIT Montageelement Dusch und Badewannenarmatur:nextVIT Montageelement Dusch und Badewannenarmatur, nextVIT Montageelement Dusch und Badewannenarmatur:nextVIT Montageelement Dusch und Badewannenarmatur:9450203
In: Ebene 0
Type - Material: MEPA Steel, MEPA Wood, MEPA Plastic red 255-0-0, MEPA Plastic black 90-90-90, MEPA Steel black 80-80-80
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für Dusch- oder Badewannenarmatur Unterputz - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - werkzeuglos höhenverstellbare, rutschhemmende UP-Armaturenplatte, tiefenverstellbar von 80-160 mm - Elementhöhe erweiterbar von 1150 bis 1325 mm LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - UP-Armaturenplatte Schichtholzplatte 390x200x21 mm - Fußverlängerungsset 175 mm - Befestigungsmaterial ZUBEHÖR - Wandwinkel Einzelmontage EC-Technik (Art.-Nr. 541023) HINWEISE - kürzbar bis Systembauhöhe 850 mm mit Umbauset C-Schiene EC Systembauhöhe 85-100 (Art.-Nr. 542052); MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952028001; MEPA_ID: 549015; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT Montageelement Dusch-/Badewannenarmatur UP; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 9.9 Kilogramm

# IfcFlowTerminal: nextVIT Montagemodul STLBW Waschtisch Einlochbatterie:nextVIT Montagemodul STLBW Waschtisch Einlochbatterie, nextVIT Montagemodul STLBW Waschtisch Einlochbatterie:nextVIT Montagemodul STLBW Waschtisch Einlochbatterie:7637694
In: Ebene 0
Type - Material: MEPA Steel, MEPA Grey Glossy, MEPA White Glossy, MEPA Plastic red 255-0-0, MEPA Plastic black 90-90-90, MEPA Polystyrene grey
IFC Export - MEPA_Description: VERWENDUNGSZWECK - vormontierte Anschlusstraverse für Waschtisch-Einlochbatterie - für Trockenbaumontage - zur Einzelmontage in eine Ständerleichtbauwand EIGENSCHAFTEN - sendzimir-verzinktes C-Profil LIEFERUMFANG - 2 Montageplatten zur Aufnahme handelsüblicher Wandscheiben - höhenverstellbarer Ablaufbogenhalter - HT-Ablaufbogen DN 40/50 mit Gummimanschette NW 32/40, kürzbar, mit Bauschutzstopfen - Befestigungsmaterial HINWEISE Kein Verwendungshinweis notwendig; MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952025758; MEPA_ID: 547009; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT Montagemodul Ständerleichtbau Waschtisch ELB; MEPA_Order Quantity: 1; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 2.1 Kilogramm

# IfcFlowTerminal: nextVIT Stand-WC-Element Typ A31 SBH 120 BabyKinder:nextVIT Stand-WC-Element Typ A31 SBH 120 BabyKinder, nextVIT Stand-WC-Element Typ A31 SBH 120 BabyKinder:nextVIT Stand-WC-Element Typ A31 SBH 120 BabyKinder:9419840
In: Ebene 0
Type - Material: MEPA Porcelain white, MEPA White Matte, MEPA Plastic red 255-0-0, MEPA Steel, MEPA Polystyrene grey, MEPA Plastic black 90-90-90, <Unnamed>, MEPA Steel black 80-80-80
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für kindgerechtes Stand-WC - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - UP-Spülkasten Sanicontrol Typ A31 - 2-Mengen- oder 1-Mengen- oder Start/Stopp-Spültechnik - EasyConnect-System für werkzeuglose Montage am Spülkasten - Spülkasten komplett vormontiert - Prüfung und CE-Kennzeichnung gemäß DIN EN 14 055 - Wasseranschluss links oder hinten - Spülmenge 6/3 l (Werkseinstellung) - Spülmengen getrennt einstellbar: große Spülmenge 5 - 7 l, stufenlos kleine Spülmenge 3 - 4,5 l, stufenlos - maximales Spülvolumen 7,5 l - bei Werkseinstellung sofortiges Nachspülen möglich - integrierte Spülstromdrossel zur stufenlosen Reduzierung des Spülstroms von ca. 2,2 l/s (min. Drosselung) bis ca. 1,8 l/s (max. Drosselung) - schwitzwassergedämmt - 25 Jahre Ersatzteilgarantie gemäß den MEPA-Garantiebedingungen - mechanische Betätigung von vorn - WC-Anschlussbogen 3-fach tiefenverstellbar - Anschlüsse Zu - und Ablauf parallel stufenlos höhenverstellbar: Zulauf 250-300 mm Ablauf 120-170 mm LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - Wasseranschluss G 1/2 A mit integriertem Eckventil und Handrad - Bauschutzkasten für Revisionsöffnung - 2 Schutzstopfen - Befestigungsmaterial ZUBEHÖR - Wandwinkel Einzelmontage EC-Technik (Art.-Nr. 541023) - Betätigungsplatten Serie MEPA Zero Lumo - Betätigungsplatten Serie MEPA Zero - Betätigungsplatten Serie MEPA Orbit - Betätigungsplatten Serie MEPA Frame - Betätigungsplatten Serie MEPA Sun HINWEISE - WC-Anschlussgarnitur für Stand-WC im Lieferumfang nicht enthalten - Die Höhe der Revisionsöffnung wandert um das eingestellte Maß mit: 1045-845 mm - Ausführliche Informationen zu den MEPA Garantiebedingungen finden Sie unter: www.mepa.de/mepa/Garantie; MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952027448; MEPA_ID: 514812; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT Stand-WC-Element Typ A31 Systembauhöhe 120 Baby/Kinder; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 13.5 Kilogramm

# IfcFlowTerminal: nextVIT Step-WC-Element Typ A31 SBH 120:nextVIT Step-WC-Element Typ A31 SBH 120, nextVIT Step-WC-Element Typ A31 SBH 120:nextVIT Step-WC-Element Typ A31 SBH 120:9420068
In: Ebene 0
Type - Material: MEPA White Matte, MEPA Porcelain white, MEPA Plastic red 255-0-0, MEPA Steel, MEPA Polystyrene grey, MEPA Plastic black 90-90-90, <Unnamed>, MEPA Steel black 80-80-80
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für wandhängendes WC - zur nachträglichen WC-Höhenverstellung - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - UP-Spülkasten Sanicontrol Typ A31 - 2-Mengen- oder 1-Mengen- oder Start/Stopp-Spültechnik - EasyConnect-System für werkzeuglose Montage am Spülkasten - Spülkasten komplett vormontiert - Prüfung und CE-Kennzeichnung gemäß DIN EN 14 055 - Wasseranschluss links oder hinten - Spülmenge 6/3 l (Werkseinstellung) - Spülmengen getrennt einstellbar: große Spülmenge 5 - 7 l, stufenlos kleine Spülmenge 3 - 4,5 l, stufenlos - maximales Spülvolumen 7,5 l - bei Werkseinstellung sofortiges Nachspülen möglich - integrierte Spülstromdrossel zur stufenlosen Reduzierung des Spülstroms von ca. 2,2 l/s (min. Drosselung) bis ca. 1,8 l/s (max. Drosselung) - schwitzwassergedämmt - 25 Jahre Ersatzteilgarantie gemäß den MEPA-Garantiebedingungen - mechanische Betätigung von vorn - WC-Anschlussbogen 3-fach tiefenverstellbar - WC-Höhenverstellung: verstellbare Bolzenhöhe 340-380 mm, WC-Befestigungsbolzen auch nach dem Verfliesen höhenverstellbar LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - Wasseranschluss G 1/2 A mit integriertem Eckventil und Handrad - PE Wand-WC-Anschlussbogen DN 90 - PE Wand-WC-Anschlussgarnitur DN 90 - PE Übergangsstück DN 90/110 - Wand-WC-Befestigungsset M12 - Bauschutzkasten für Revisionsöffnung - 2 Schutzstopfen - Befestigungsmaterial ZUBEHÖR - Wandwinkel Einzelmontage EC-Technik (Art.-Nr. 541023) - Betätigungsplatten Serie MEPA Zero Lumo - Betätigungsplatten Serie MEPA Zero - Betätigungsplatten Serie MEPA Orbit - Betätigungsplatten Serie MEPA Frame - Betätigungsplatten Serie MEPA Sun HINWEISE - Anschluss von Dusch-WC-Systemen nicht möglich - Ausführliche Informationen zu den MEPA Garantiebedingungen finden Sie unter: www.mepa.de/mepa/garantie; MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952027455; MEPA_ID: 514813; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT Step-WC-Element Typ A31 Systembauhöhe 120; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 17.3 Kilogramm

# IfcFlowTerminal: nextVIT Stütz-Stützklappgriff-Element:nextVIT Stütz-Stützklappgriff-Element (2)
In: Ebene 0
Type - Material: MEPA Plastic red 255-0-0, MEPA Steel, MEPA Plastic black 90-90-90, MEPA Steel black 80-80-80, MEPA Wood
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für Stütz- oder Stützklappgriffe - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand - zur Montage gemäß DIN 18 040 EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragendes Montageelement - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichtete Stütze - höhenverstellbare Fußstütze 0-240 mm mit integrierter Rutschhemmung, Fußplatte drehbar, Bohrfehler ausgleichend, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Meterrissmarkierung zur exakten Ausrichtung der Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 LIEFERUMFANG - 1 Stütze - Schichtholzplatte 200x690x38 mm - Befestigungsmaterial ZUBEHÖR - Wandwinkel Einzelmontage Barrierefrei (Art.-Nr. 541031) HINWEISE - umbaubar für linken oder rechten Anschluss an seitlich anschließendes Montageelement oder Einzelstütze; MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952027981; MEPA_ID: 549016; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT Stütz-/Stützklappgriff-Element; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 8 Kilogramm
Name (nextVIT Stütz-Stützklappgriff-Element:nextVIT Stütz-Stützklappgriff-Element:...)
7637744
7641784

# IfcFlowTerminal: nextVIT Urinal-Element AP-Spülsystem Systembauhöhe 120:nextVIT Urinal-Element AP-Spülsystem Systembauhöhe 120, nextVIT Urinal-Element AP-Spülsystem Systembauhöhe 120:nextVIT Urinal-Element AP-Spülsystem Systembauhöhe 120:7637914
In: Ebene 0
Type - Material: MEPA Steel
Material: MEPA Steel, MEPA Porcelain white, MEPA Black Matte, MEPA Steel black 80-80-80, MEPA Plastic black 90-90-90, MEPA Wood, MEPA Plastic red 255-0-0
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für Urinal mit Zulauf von oben - zur Kombination mit elektronischem oder mechanischem AP-Urinal-Spülsystem - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - werkzeuglos höhenverstellbare, rutschhemmende Anschlusstraversen für Wasseranschluss, Ablauf, Keramikbefestigung LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - Befestigung Keramik Schichtholzplatte 420x100x21 mm - 2 Stockschrauben M8 - schallgedämmte MEPA-Wandscheibe G 1/2 - Ablaufrohrschelle DN 50 - HT-Ablaufbogen DN 50 - Befestigungsmaterial ZUBEHÖR - Wandwinkel-Set zur Einzelmontage EC-Technik (Art.-Nr. 541023) HINWEISE - passende Urinal-Keramiken finden Sie unter www.mepa.de/download/planungshilfen; MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952027820; MEPA_ID: 530002; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT Urinal-Element AP-Spülsystem Systembauhöhe 120 Elektronisch/Mechanisch; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 10.6 Kilogramm

# IfcFlowTerminal: nextVIT Urinal-Element UP-Spülsystem K3 SBH 120 Elektronisch:nextVIT Urinal-Element UP-Spülsystem K3 SBH 120 Elektronisch, nextVIT Urinal-Element UP-Spülsystem K3 SBH 120 Elektronisch:nextVIT Urinal-Element UP-Spülsystem K3 SBH 120 Elektronisch:7638066
In: Ebene 0
Type - Material: MEPA Steel
Material: MEPA Steel, MEPA Porcelain white, MEPA Black Matte, MEPA Steel black 80-80-80, MEPA Wood, MEPA Plastic red 255-0-0, MEPA Plastic white, MEPA Plastic black 90-90-90
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für Urinal mit verdecktem Zulauf von hinten - für Trockenbaumontage - zur Kombination mit elektronischer, verdeckt montierter UP-Urinal-Steuerung Sanicontrol K3 - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - werkzeuglos höhenverstellbare, rutschhemmende Anschlusstraversen für Wasseranschluss, Ablauf, Keramikbefestigung - Elementhöhe auf Keramik anpassbar, erweiterbar von 1150 bis 1325 mm - für Betriebsdruck 0,3 - 10 bar - vandalensicher LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - Befestigung Keramik Schichtholzplatte 420x100x21 mm - 2 Stockschrauben M8 - schallgedämmte MEPA-Wandscheibe G 1/2 - Ablaufrohrschelle DN 50 - HT-Ablaufbogen DN 50 - Panzerschlauch DN 12 G 1/2 A x G 3/4 verdrehsicher, Länge 500 mm - Einlaufverbinder DN 15 - UP-Gehäuse für MEPA-Urinalsteuerung Sanicontrol K3, mit Wasseranschluss G 1/2 A seitlich am UP-Gehäuse - Wasserstrecke G 3/4 mit Kugelhahn, zur Vorabsperrung, vormontiert im UP-Gehäuse - Anschlussklemme für Elektroanschluss 230 VAC seitlich im UP-Gehäuse - Bauschutz Serviceöffnung, ablängbar, 130x110x30 mm - Fußverlängerungsset 175 mm - Befestigungsmaterial ZUBEHÖR - Wandwinkel-Set zur Einzelmontage EC-Technik (Art.-Nr. 541023) - Urinal-Spülautomatic Sanicontrol K3 (Art.-Nr. 718230) - Programmierstift Sanicontrol K3 (Art.-Nr. 718205) HINWEISE - geeignet für Urinale mit waagerechtem Abgang ohne angeformten Geruchsverschluss - passende Urinal-Keramiken finden Sie unter www.mepa.de/download/planungshilfen; MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952027844; MEPA_ID: 532013; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT Urinal-Element UP-Spülsystem K3 Systembauhöhe 120 Elektronisch; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 12.8 Kilogramm

# IfcFlowTerminal: nextVIT Urinal-Element UP-Spülsystem Systembauhöhe 120:nextVIT Urinal-Element UP-Spülsystem Systembauhöhe 120, nextVIT Urinal-Element UP-Spülsystem Systembauhöhe 120:nextVIT Urinal-Element UP-Spülsystem Systembauhöhe 120:7638147
In: Ebene 0
Type - Material: MEPA White Matte
Material: MEPA White Matte, MEPA Steel, MEPA Porcelain white, MEPA Black Matte, MEPA Steel black 80-80-80, MEPA Plastic black 90-90-90, MEPA Wood, MEPA Plastic red 255-0-0, MEPA Plastic white
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für Urinal mit verdecktem Zulauf von hinten - zur Kombination mit elektronischem oder mechanischem UP-Urinal-Spülsystem - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - werkzeuglos höhenverstellbare, rutschhemmende Anschlusstraversen für Wasseranschluss, Ablauf, Keramikbefestigung - Elementhöhe auf Keramik anpassbar, erweiterbar von 1150 bis 1325 mm LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - Befestigung Keramik Schichtholzplatte 420x100x21 mm - 2 Stockschrauben M8 - schallgedämmte MEPA-Wandscheibe G 1/2 - Ablaufrohrschelle DN 50 - HT-Ablaufbogen DN 50 - Panzerschlauch DN 12 G 1/2 A x G 3/4 verdrehsicher, Länge 500 mm - Einlaufverbinder DN 15 - UP-Gehäuse für MEPA-Urinalsteuerungen Sanicontrol, mit Wasseranschluss G 1/2 A oben am UP-Gehäuse - Wasserstrecke G 3/4 mit Kugelhahn, zur Vorabsperrung, vormontiert im UP-Gehäuse - Anschlussklemme für Elektroanschluss 230 VAC oben im UP-Gehäuse - Bauschutz Serviceöffnung, ablängbar, 130x110x30 mm - Fußverlängerungsset 175 mm - Befestigungsmaterial ZUBEHÖR - Wandwinkel-Set zur Einzelmontage EC-Technik (Art.-Nr. 541023) - Steuerungen Sanicontrol MEPA Orbit IR - Steuerungen Sanicontrol 925 IR - Steuerungen Sanicontrol 825 IR - UP-Druckspüler Sanicontrol MEPA Orbit - UP-Druckspüler Sanicontrol MEPA Zero - UP-Druckspüler Sanicontrol MEPA Drop HINWEISE - passende Urinal-Keramiken finden Sie unter www.mepa.de/download/planungshilfen; MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952027837; MEPA_ID: 532012; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT Urinal-Element UP-Spülsystem Systembauhöhe 120 Elektronisch/Mechanisch; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 13 Kilogramm

# IfcFlowTerminal: nextVIT WC-Element Typ A31 SBH 120 Geruchsabsaugeanschluss:nextVIT WC-Element Typ A31 SBH 120 Geruchsabsaugeanschluss, nextVIT WC-Element Typ A31 SBH 120 Geruchsabsaugeanschluss:nextVIT WC-Element Typ A31 SBH 120 Geruchsabsaugeanschluss:9007708
In: Ebene 0
Type - Material: MEPA White Matte, MEPA Porcelain white, MEPA Plastic red 255-0-0, MEPA Steel, MEPA Polystyrene grey, MEPA Plastic black 90-90-90, <Unnamed>, MEPA Steel black 80-80-80
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für wandhängendes WC - zum Anschließen einer externen Geruchsabsaugung - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - UP-Spülkasten Sanicontrol Typ A31 - 2-Mengen- oder 1-Mengen- oder Start/Stopp-Spültechnik - EasyConnect-System für werkzeuglose Montage am Spülkasten - Spülkasten komplett vormontiert - Prüfung und CE-Kennzeichnung gemäß DIN EN 14 055 - Wasseranschluss links oder hinten - Spülmenge 6/3 l (Werkseinstellung) - Spülmengen getrennt einstellbar: große Spülmenge 5 - 7 l, stufenlos kleine Spülmenge 3 - 4,5 l, stufenlos - maximales Spülvolumen 7,5 l - bei Werkseinstellung sofortiges Nachspülen möglich - integrierte Spülstromdrossel zur stufenlosen Reduzierung des Spülstroms von ca. 2,2 l/s (min. Drosselung) bis ca. 1,8 l/s (max. Drosselung) - schwitzwassergedämmt - 25 Jahre Ersatzteilgarantie gemäß den MEPA-Garantiebedingungen - mechanische Betätigung von vorn - WC-Anschlussbogen 3-fach tiefenverstellbar - externe Geruchsabsaugung mit Anschlussmuffe DN 50 über Spülrohrbogen anschließbar - Anschluss Dusch-WC-Systeme möglich LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - Wasseranschluss G 1/2 A mit integriertem Eckventil und Handrad - PE Wand-WC-Anschlussbogen DN 90 - PE Wand-WC-Anschlussgarnitur DN 90 - PE Übergangsstück DN 90/110 - Wand-WC-Befestigungsset M12 - Bauschutzkasten für Revisionsöffnung - 2 Schutzstopfen - Befestigungsmaterial ZUBEHÖR - Wandwinkel Einzelmontage EC-Technik (Art.-Nr. 541023) - Betätigungsplatten Serie MEPA Zero Lumo - Betätigungsplatten Serie MEPA Zero - Betätigungsplatten Serie MEPA Orbit - Betätigungsplatten Serie MEPA Frame - Betätigungsplatten Serie MEPA Sun HINWEISE - Für bestimmte WC-Keramiken nicht geeignet. Eine ständig aktualisierte Liste von WC-Keramiken, die mit diesem WC-System mit Geruchsabsaugeanschluss nicht kompatibel sind, finden Sie unter: www.mepa.de/Download/Planungshilfen - Ausführliche Informationen zu den MEPA Garantiebedingungen finden Sie unter: www.mepa.de/mepa/garantie; MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952027479; MEPA_ID: 514822; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT WC-Element Typ A31 Systembauhöhe 120 Geruchsabsaugeanschluss; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 17 Kilogramm

# IfcFlowTerminal: nextVIT WC-Element Typ A31 Systembauhöhe 120 Barrierefrei:nextVIT WC-Element Typ A31 Systembauhöhe 120 Barrierefrei, nextVIT WC-Element Typ A31 Systembauhöhe 120 Barrierefrei:nextVIT WC-Element Typ A31 Systembauhöhe 120 Barrierefrei:7638396
In: Ebene 0
Type - Material: MEPA Plastic red 255-0-0, MEPA Steel, MEPA Steel black 80-80-80, MEPA Wood, MEPA White Matte, MEPA Porcelain white, MEPA Polystyrene grey, MEPA Plastic black 90-90-90, <Unnamed>
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für barrierefreies wandhängendes WC - zur Montage gemäß DIN 18 040 - zur Montage von WC-Keramiken mit verlängerter Ausladung bis 700 mm - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand - zur Montage von Stütz- oder Stützklappgriffen EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - UP-Spülkasten Sanicontrol Typ A31 - 2-Mengen- oder 1-Mengen- oder Start/Stopp-Spültechnik - EasyConnect-System für werkzeuglose Montage am Spülkasten - Spülkasten komplett vormontiert - Prüfung und CE-Kennzeichnung gemäß DIN EN 14 055 - Wasseranschluss links oder hinten - Spülmenge 6/3 l (Werkseinstellung) - Spülmengen getrennt einstellbar: große Spülmenge 5 - 7 l, stufenlos kleine Spülmenge 3 - 4,5 l, stufenlos - maximales Spülvolumen 7,5 l - bei Werkseinstellung sofortiges Nachspülen möglich - integrierte Spülstromdrossel zur stufenlosen Reduzierung des Spülstroms von ca. 2,2 l/s (min. Drosselung) bis ca. 1,8 l/s (max. Drosselung) - schwitzwassergedämmt - 25 Jahre Ersatzteilgarantie gemäß den MEPA-Garantiebedingungen - mechanische Betätigung von vorn - WC-Anschlussbogen 3-fach tiefenverstellbar - Anschluss Dusch-WC-Systeme möglich - voreingestellt für Sitzhöhe 48 cm LIEFERUMFANG - 2 Wandwinkel-Set zur Einzelmontage vor Massivwand - Montage-Set zur Montage in Ständerleichtbauwand - Wasseranschluss G 1/2 A mit integriertem Eckventil und Handrad - PE Wand-WC-Anschlussbogen DN 90 - PE Wand-WC-Anschlussgarnitur DN 90 - PE Übergangsstück DN 90/110 - Wand-WC-Befestigungsset M12 - Bauschutzkasten für Revisionsöffnung - 2 Schutzstopfen - 2 Schichtholzplatten 200x690x38 mm - Befestigungsmaterial ZUBEHÖR - Betätigungsplatten Serie MEPA Zero - Betätigungsplatten Serie MEPA Orbit - Betätigungsplatten Serie MEPA Sun - Betätigungsplatten Serie MEPA Frame HINWEISE - Mindesteinbautiefe in Ständerleichtbauwand 200 mm - Erweiterung mit Sanicontrol 1061 WC-Steuerung für Stützklappgriffe mit E-Taster möglich - WC-Rohbauset Anschluss Stützklappgriffe E-Taster (Art.Nr. 548016) - Erweiterung mit Sanicontrol 1065 WC-Steuerung für Stützklappgriffe mit Funksender möglich - Ausführliche Informationen zu den MEPA Garantiebedingungen finden Sie unter: www.mepa.de/mepa/garantie; MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952027332; MEPA_ID: 513111; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT WC-Element Typ A31 Systembauhöhe 120 Barrierefrei mit Stützklappgriff-Elementen; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 36 Kilogramm

# IfcFlowTerminal: nextVIT WC-Element Typ A31 Systembauhöhe 120 Barrierefrei:nextVIT WC-Element Typ A31 Systembauhöhe 120 Barrierefrei, nextVIT WC-Element Typ A31 Systembauhöhe 120 Barrierefrei:nextVIT WC-Element Typ A31 Systembauhöhe 120 Barrierefrei:7642642
In: Ebene 0
Type - Material: MEPA White Matte, MEPA Porcelain white, MEPA Plastic red 255-0-0, MEPA Steel, MEPA Polystyrene grey, MEPA Plastic black 90-90-90, <Unnamed>, MEPA Steel black 80-80-80
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für barrierefreies wandhängendes WC - zur Montage gemäß DIN 18 040 - zur Montage von WC-Keramiken mit verlängerter Ausladung bis 700 mm - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - UP-Spülkasten Sanicontrol Typ A31 - 2-Mengen- oder 1-Mengen- oder Start/Stopp-Spültechnik - EasyConnect-System für werkzeuglose Montage am Spülkasten - Spülkasten komplett vormontiert - Prüfung und CE-Kennzeichnung gemäß DIN EN 14 055 - Wasseranschluss links oder hinten - Spülmenge 6/3 l (Werkseinstellung) - Spülmengen getrennt einstellbar: große Spülmenge 5 - 7 l, stufenlos kleine Spülmenge 3 - 4,5 l, stufenlos - maximales Spülvolumen 7,5 l - bei Werkseinstellung sofortiges Nachspülen möglich - integrierte Spülstromdrossel zur stufenlosen Reduzierung des Spülstroms von ca. 2,2 l/s (min. Drosselung) bis ca. 1,8 l/s (max. Drosselung) - schwitzwassergedämmt - 25 Jahre Ersatzteilgarantie gemäß den MEPA-Garantiebedingungen - mechanische Betätigung von vorn - WC-Anschlussbogen 3-fach tiefenverstellbar - Anschluss Dusch-WC-Systeme möglich - voreingestellt für Sitzhöhe 48 cm LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - Wasseranschluss G 1/2 A mit integriertem Eckventil und Handrad - PE Wand-WC-Anschlussbogen DN 90 - PE Wand-WC-Anschlussgarnitur DN 90 - PE Übergangsstück DN 90/110 - Wand-WC-Befestigungsset M12 - Bauschutzkasten für Revisionsöffnung - 2 Schutzstopfen - Befestigungsmaterial ZUBEHÖR - Wandwinkel Einzelmontage Barrierefrei EC (Art.Nr. 541031) - Betätigungsplatten Serie MEPA Zero - Betätigungsplatten Serie MEPA Orbit - Betätigungsplatten Serie MEPA Sun - Betätigungsplatten Serie MEPA Frame HINWEISE - Mindesteinbautiefe in Ständerleichtbauwand 200 mm - Erweiterung mit Stütz-/Stützklappgriff-Element möglich (Art.-Nr. 549016) - Erweiterung mit Sanicontrol 1061 WC-Steuerung für Stützklappgriffe mit E-Taster möglich - WC-Rohbauset Anschluss Stützklappgriff E-Taster. (Art.-Nr. 548016) - Erweiterung mit Sanicontrol 1065 WC-Steuerung für Stützklappgriffe mit Funksender möglich - Ausführliche Informationen zu den MEPA Garantiebedingungen finden Sie unter: www.mepa.de/mepa/garantie; MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952027325; MEPA_ID: 513110; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT WC-Element Typ A31 Systembauhöhe 120 Barrierefrei; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 17.5 Kilogramm

# IfcFlowTerminal: nextVIT WC-Element Typ A31(P31) Systembauhöhe 120:nextVIT WC-Element Typ A31(P31) Systembauhöhe 120, nextVIT WC-Element Typ A31(P31) Systembauhöhe 120:nextVIT WC-Element Typ A31(P31) Systembauhöhe 120:7638464
In: Ebene 0
Type - Material: MEPA White Matte, MEPA Porcelain white, MEPA Plastic red 255-0-0, MEPA Steel, MEPA Polystyrene grey, MEPA Plastic black 90-90-90, <Unnamed>, MEPA Steel black 80-80-80
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für wandhängendes WC - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - UP-Spülkasten Sanicontrol Typ A31 - 2-Mengen- oder 1-Mengen- oder Start/Stopp-Spültechnik - EasyConnect-System für werkzeuglose Montage am Spülkasten - Spülkasten komplett vormontiert - Prüfung und CE-Kennzeichnung gemäß DIN EN 14 055 - Wasseranschluss links oder hinten - Spülmenge 6/3 l (Werkseinstellung) - Spülmengen getrennt einstellbar: große Spülmenge 5 - 7 l, stufenlos kleine Spülmenge 3 - 4,5 l, stufenlos - maximales Spülvolumen 7,5 l - bei Werkseinstellung sofortiges Nachspülen möglich - integrierte Spülstromdrossel zur stufenlosen Reduzierung des Spülstroms von ca. 2,2 l/s (min. Drosselung) bis ca. 1,8 l/s (max. Drosselung) - schwitzwassergedämmt - 25 Jahre Ersatzteilgarantie gemäß den MEPA-Garantiebedingungen - mechanische Betätigung von vorn - WC-Anschlussbogen 3-fach tiefenverstellbar - Anschluss Dusch-WC-Systeme möglich LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - Wasseranschluss G 1/2 A mit integriertem Eckventil und Handrad - PE Wand-WC-Anschlussbogen DN 90 - PE Wand-WC-Anschlussgarnitur DN 90 - PE Übergangsstück DN 90/110 - Wand-WC-Befestigungsset M12 - Bauschutzkasten für Revisionsöffnung - 2 Schutzstopfen - Befestigungsmaterial ZUBEHÖR - Wandwinkel Einzelmontage EC-Technik (Art.-Nr. 541023) - Betätigungsplatten Serie MEPA Zero Lumo - Betätigungsplatten Serie MEPA Zero - Betätigungsplatten Serie MEPA Orbit - Betätigungsplatten Serie MEPA Frame - Betätigungsplatten Serie MEPA Sun HINWEISE - Ausführliche Informationen zu den MEPA Garantiebedingungen finden Sie unter: www.mepa.de/mepa/garantie; MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952027356; MEPA_ID: 514105; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT WC-Element Typ A31 Systembauhöhe 120; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 15.4 Kilogramm

# IfcFlowTerminal: nextVIT WC-Element Typ A31(P31) Systembauhöhe 120:nextVIT WC-Element Typ A31(P31) Systembauhöhe 120, nextVIT WC-Element Typ A31(P31) Systembauhöhe 120:nextVIT WC-Element Typ A31(P31) Systembauhöhe 120:7643403
In: Ebene 0
Type - Material: MEPA White Matte, MEPA Porcelain white, MEPA Steel, MEPA Polystyrene grey, MEPA Plastic black 90-90-90, <Unnamed>, MEPA Steel black 80-80-80
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für wandhängendes WC - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - sendzimir verzinkter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm Fußplatten drehbar, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - UP-Spülkasten Sanicontrol Typ P31 - 2-Mengen oder 1-Mengen- oder Start/Stopp-Spültechnik - EasyConnect-System für werkzeuglose Montage am Spülkasten - Spülkasten komplett vormontiert - Prüfung und CE-Kennzeichnung gemäß DIN EN 14 055 - Wasseranschluss links oder hinten - Spülmenge 6/3 l (Werkseinstellung) - Spülmengen getrennt einstellbar: große Spülmenge 5 - 7 l, stufenlos kleine Spülmenge 3 - 4,5 l, stufenlos - maximales Spülvolumen 7,5 l - bei Werkseinstellung sofortiges Nachspülen möglich - schwitzwassergedämmt - 25 Jahre Ersatzteilgarantie - mechanische Betätigung von vorn - WC-Anschlussbogen 3-fach tiefenverstellbar LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - Wasseranschluss G 1/2 A mit integriertem Eckventil und Handrad - PE Wand-WC-Anschlussbogen DN 90 - PE Wand-WC-Anschlussgarnitur DN 90 - Wand-WC-Befestigungsset M12 - Bauschutzkasten für Revisionsöffnung - 2 Schutzstopfen - Befestigungsmaterial ZUBEHÖR - Wandwinkel Einzelmontage ECO (Art.-Nr. 541027) - Wandwinkel Einzelmontage EC-Technik (Art.-Nr. 541023) - Betätigungsplatten Serie MEPA Zero Lumo - Betätigungsplatten Serie MEPA Zero - Betätigungsplatten Serie MEPA Orbit - Betätigungsplatten Serie MEPA Sun - Betätigungsplatten Serie MEPA Frame HINWEISE Kein Verwendungshinweis notwendig; MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952030882; MEPA_ID: 512341; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT WC-Element Typ P31 ECO Systembauhöhe 120; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 15 Kilogramm

# IfcFlowTerminal: nextVIT WT-Element Einloch-Wandbatterie Systembauhöhe 120 Barrierefrei:nextVIT WT-Element Einloch-Wandbatterie Systembauhöhe 120 Barrierefrei, nextVIT WT-Element Einloch-Wandbatterie Systembauhöhe 120 Barrierefrei:nextVIT WT-Element Einloch-Wandbatterie Systembauhöhe 120 Barrierefrei:7638604
In: Ebene 0
Type - Material: MEPA Steel, MEPA Grey Glossy, MEPA White Glossy, MEPA Plastic red 255-0-0, MEPA Plastic black 90-90-90, MEPA Steel black 80-80-80, MEPA Plastic white
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für barrierefreie Waschtisch-Einloch- oder -Wandbatterie - zur Montage gemäß DIN 18 040 - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - werkzeuglos höhenverstellbare, rutschhemmende Anschlusstraversen für Wasseranschluss, Ablauf, Keramikbefestigung - Lochabstand Keramikbefestigung 150-240 mm und 280 mm - Montage handelsüblicher Wandscheiben G 1/2 möglich LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - 2 schallgedämmte MEPA-Wandscheiben G 1/2 - UP-Sipon mit verchromtem Anschlussrohr und Abdeckplatte Kunststoff verchromt, Geruchsverschluss im UP-Gehäuse 50 mm höhenverstellbar, herausnehmbar - 2 Gewindebolzen M10 - Befestigungsmaterial ZUBEHÖR - Wandwinkel-Set zur Einzelmontage EC-Technik (Art.-Nr. 541023) HINWEISE Kein Verwendungshinweis notwendig; MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952027790; MEPA_ID: 524002; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT Waschtisch-Element Einloch-/Wandbatterie Systembauhöhe 120 Barrierefrei; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 12.6 Kilogramm

# IfcFlowTerminal: nextVIT WT-Element Einlochbatterie Systembauhöhe 120 Möbelwaschtisch:nextVIT WT-Element Einlochbatterie Systembauhöhe 120 Möbelwaschtisch, nextVIT WT-Element Einlochbatterie Systembauhöhe 120 Möbelwaschtisch:nextVIT WT-Element Einlochbatterie Systembauhöhe 120 Möbelwaschtisch:7638734
In: Ebene 0
Type - Material: MEPA Steel, MEPA Grey Glossy, MEPA White Glossy, MEPA Plastic red 255-0-0, MEPA Plastic black 90-90-90, MEPA Steel black 80-80-80, MEPA Polystyrene grey
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für Möbel-Waschtisch-Einlochbatterie - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - werkzeuglos höhenverstellbare, rutschhemmende Anschlusstraversen für Wasseranschluss, Ablauf, Keramikbefestigung - Lochabstand Keramikbefestigung 40-310 mm - Montage handelsüblicher Wandscheiben G 1/2 möglich LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - 2 schallgedämmte MEPA-Wandscheiben G 1/2 - höhenverstellbarer Ablaufbogenhalter - HT-Ablaufbogen DN 40/50 mit Gummimanschette NW 32/40, kürzbar, mit Bauschutzstopfen - 2 Gewindebolzen M10 - Befestigungsmaterial ZUBEHÖR - Wandwinkel Einzelmontage EC-Technik (Art.-Nr. 541023) HINWEISE - kürzbar bis Systembauhöhe 850 mm mit Umbauset C-Schiene EC Systembauhöhe 85-100 (Art.-Nr. 542052) - zur Montage von Möbelwaschtischen wird zusätzlich das Montageelement für Stützklappgriffe (Art.-Nr. 549016) benötigt; Je nach Baubreite, die abhänig vom Stichmaß der Befestigungspunkte des Möbelwaschtisches ist, sind die Stützklappgriffelemente zu befestigen oder mit 2 zusätzlichen Stützen (Art.-Nr. 541022) zu montieren; MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952027691; MEPA_ID: 521022; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT Waschtisch-Element Einlochbatterie Systembauhöhe 120 Möbelwaschtisch; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 11.7 Kilogramm

# IfcFlowTerminal: nextVIT WT-Element Einlochbatterie Systembauhöhe 120:nextVIT WT-Element Einlochbatterie Systembauhöhe 120, nextVIT WT-Element Einlochbatterie Systembauhöhe 120:nextVIT WT-Element Einlochbatterie Systembauhöhe 120:7638674
In: Ebene 0
Type - Material: MEPA Steel, MEPA Grey Glossy, MEPA White Glossy, MEPA Black Matte, MEPA Steel black 80-80-80, MEPA Plastic red 255-0-0, MEPA Plastic black 90-90-90, MEPA Polystyrene grey
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für Waschtisch-Einlochbatterie - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - werkzeuglos höhenverstellbare, rutschhemmende Anschlusstraversen für Wasseranschluss, Ablauf, Keramikbefestigung - Lochabstand Keramikbefestigung 150-240 mm und 280 mm - Montage handelsüblicher Wandscheiben G 1/2 möglich LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - 2 Montageplatten zur Aufnahme handelsüblicher Wandscheiben - höhenverstellbarer Ablaufbogenhalter - HT-Ablaufbogen DN 40/50 mit Gummimanschette NW 32/40, kürzbar, mit Bauschutzstopfen - 2 Gewindebolzen M10 - Befestigungsmaterial ZUBEHÖR - Wandwinkel Einzelmontage EC-Technik (Art.-Nr. 541023) HINWEISE - kürzbar bis Systembauhöhe 850 mm mit Umbauset C-Schiene EC Systembauhöhe 85-100 (Art.-Nr. 542052); MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952027684; MEPA_ID: 521017; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT Waschtisch-Element Einlochbatterie Systembauhöhe 120; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 10 Kilogramm

# IfcFlowTerminal: nextVIT WT-Element Einlochbatterie Systembauhöhe 120:nextVIT WT-Element Einlochbatterie Systembauhöhe 120, nextVIT WT-Element Einlochbatterie Systembauhöhe 120:nextVIT WT-Element Einlochbatterie Systembauhöhe 120:7643585
In: Ebene 0
Type - Material: MEPA Steel, MEPA Grey Glossy, MEPA White Glossy, MEPA Plastic red 255-0-0, MEPA Plastic black 90-90-90, MEPA Steel black 80-80-80, MEPA Polystyrene grey
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für Waschtisch-Einlochbatterie - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - pulverbeschichteter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm mit integrierter Rutschhemmung, Fußplatten drehbar, Bohrfehler ausgleichend, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - werkzeuglos höhenverstellbare, rutschhemmende Anschlusstraversen für Wasseranschluss, Ablauf, Keramikbefestigung - Lochabstand Keramikbefestigung 150-240 mm und 280 mm - Montage handelsüblicher Wandscheiben G 1/2 möglich LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - 2 Montageplatten zur Aufnahme handelsüblicher Wandscheiben - 2 schallgedämmte MEPA-Wandscheiben G 1/2 - höhenverstellbarer Ablaufbogenhalter - HT-Ablaufbogen DN 40/50 mit Gummimanschette NW 32/40, kürzbar, mit Bauschutzstopfen - 2 Gewindebolzen M10 - Befestigungsmaterial ZUBEHÖR - Wandwinkel Einzelmontage EC-Technik (Art.-Nr. 541023) HINWEISE - kürzbar bis Systembauhöhe 850 mm mit Umbauset C-Schiene EC Systembauhöhe 85-100 (Art.-Nr. 542052); MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952027677; MEPA_ID: 521016; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT Waschtisch-Element Einlochbatterie Systembauhöhe 120; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 9.4 Kilogramm

# IfcFlowTerminal: nextVIT WT-Element Einlochbatterie Systembauhöhe 120:nextVIT WT-Element Einlochbatterie Systembauhöhe 120, nextVIT WT-Element Einlochbatterie Systembauhöhe 120:nextVIT WT-Element Einlochbatterie Systembauhöhe 120:7643596
In: Ebene 0
Type - Material: MEPA Steel, MEPA Grey Glossy, MEPA White Glossy, MEPA Steel black 80-80-80, MEPA Plastic red 255-0-0, MEPA Plastic black 90-90-90, MEPA Polystyrene grey
IFC Export - MEPA_Order Quantity: 1; MEPA_Description: VERWENDUNGSZWECK - vormontiertes Montageelement für Waschtisch-Einlochbatterie - für Trockenbaumontage - zur Einzelmontage vor eine Massiv- oder in eine Ständerleichtbauwand - zur Schienenmontage vor eine Massiv- oder vor eine Ständerleichtbauwand EIGENSCHAFTEN - Systembauhöhe 1200 mm - selbsttragender Montagerahmen - geeignet zur Beplankung mit Gipsfaser- oder Gipskartonplatten - sendzimir verzinkter Profilrahmen - höhenverstellbare Fußstützen 0-240 mm, Fußplatten drehbar, Tiefe passend zum Einbau in UW-Profil UW 50 und UW 75 und MEPA-C-Profil - Mittel- und Meterrissmarkierung zur exakten Ausrichtung der Achsmitte und Montagehöhe des Elementes - geeignet zur Wandbefestigung mit Stockschrauben M10 - höhenverstellbare, rutschhemmende Anschlusstraversen für Wasseranschluss, Ablauf, Keramikbefestigung - Lochabstand Keramikbefestigung 150-240 mm und 280 mm - Montage handelsüblicher Wandscheiben G1/2 möglich LIEFERUMFANG - Montage-Set zur Montage in Ständerleichtbauwand - 2 Montageplatten zur Aufnahme handelsüblicher Wandscheiben - höhenverstellbarer Ablaufbogenhalter - HT-Ablaufbogen DN 40/50 mit Gummimanschette NW 32/40, kürzbar, mit Bauschutzstopfen - 2 Gewindebolzen M10 - Befestigungsmaterial ZUBEHÖR - Wandwinkel Einzelmontage ECO (Art.-Nr. 541027) - Wandwinkel Einzelmontage EC-Technik (Art.-Nr. 541023) HINWEISE - kürzbar bis Systembauhöhe 850 mm mit Umbauset C-Schiene EC Systembauhöhe 85-100 (Art.-Nr. 542052); MEPA_ETIM Code: N/A; MEPA_ETIM URL: N/A; MEPA_GTIN: 4027952030899; MEPA_ID: 521023; MEPA_Manufacturer: MEPA; MEPA_Name: nextVIT Waschtisch-Element ELB ECO Systembauhöhe 120; MEPA_Version: 1.04; MEPA_Version Date: 16.12.2025; MEPA_Weight: 9.58 Kilogramm

# IfcFlowTerminal: nextVIT WT-Element Wandbatterie Systembauhöhe 120:nextVIT WT-Element Wandbatterie Systembauhöhe 120, nextVIT WT-Element Wandbatterie Systembauhöhe 120:nextVIT WT-Element Wandbatterie Systembauhöhe 120:7638789
In: Ebene 0
Type - Material: MEPA Grey Glossy, MEPA White Glossy, MEPA Plastic red 255-0-0, MEPA Steel, MEPA Plastic black 90-90-90, MEPA Steel black 80-80-80, MEPA Wood
